options:
  parameters:
    generate_options: qt_gui
    id: acumulador
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '-0.5'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python
      # -*- coding: utf-8 -*-
      #

      from gnuradio import gr
      import numpy as np

      class Acumulador(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(self,
                  name="Acumulador",
                  in_sig=[np.float32],
                  out_sig=[np.float32])
              self.cum_sum = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]
              
              for i in range(len(x)):
                  suma = x[i]
                  self.cum_sum += suma
                  y[i] = self.cum_sum

              return len(y)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: salida
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: entrada
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
